# Keil uVision project LSD4RF-Test2002.uvprojx, settings and files
target RX (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: LSD4RF-Test2002 +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;..\Drivers\STM32L4xx_HAL_Driver\Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\HARDWARE\Board\LED;..\HARDWARE\Board\KEY;..\HARDWARE\Board\EXTI;..\HARDWARE\Board\LCD;..\HARDWARE\Board\SPI;..\HARDWARE\Board\TIMER;..\HARDWARE\SX126X;..\HARDWARE\Board\BEEP;..\HARDWARE\Board\USART;..\HARDWARE\protocol;..\HARDWARE\Board\Flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c
  group HARDWARE
    ../HARDWARE/Board/LED/: led.c
    ../HARDWARE/Board/KEY/: key.c
    ../HARDWARE/Board/TIMER/: timer.c
    ../HARDWARE/Board/BEEP/: beep.c
    ../HARDWARE/SX126X/: SX126X_Driver.c SX126X_Hal.c
    ../HARDWARE/Board/LCD/: OLED.C
    ../HARDWARE/Board/Flash/: STM32L4_Flash.c
    ../HARDWARE/Board/USART/: usart.c
    ../HARDWARE/protocol/: data_pro.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: main_TX.c main_RX.c stm32l4xx_it.c stm32l4xx_hal_msp.c
    ../: 修改日志.txt
target TX (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: as above
  output: LSD4RF-Test2002 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;..\Drivers\STM32L4xx_HAL_Driver\Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\HARDWARE\Board\LED;..\HARDWARE\Board\KEY;..\HARDWARE\Board\EXTI;..\HARDWARE\Board\TIMER;..\HARDWARE\SX126X;..\HARDWARE\Board\BEEP;..\HARDWARE\Board\LCD;..\HARDWARE\Board\Flash;..\HARDWARE\Board\USART;..\HARDWARE\protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.1.0
